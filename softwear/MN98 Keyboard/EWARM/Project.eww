<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MN98 Keyboard.ewp</path>
  </project>
  <batchBuild />
</workspace>
